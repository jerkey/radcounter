# Keil uVision project arm-rad1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuC7060 Analog Devices
  cpu: IRAM(0x40000-0x40FFF) IROM(0x80000-0x877FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: arm-rad1 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x80000 size 0x7800
  memory RVCT9: RAM 0x40000 size 0x1000
  group Source Group 1
    ./: ADuC706x.s ADC0_Thermocouple.c irq_arm.c
